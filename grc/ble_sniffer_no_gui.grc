options:
  parameters:
    author: Zhongjun Yu
    generate_options: no_gui
    id: ble_sniffer_no_gui
    output_language: python
    title: BLE air sniffer
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gmsk_gain_mu
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: gmsk_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gmsk_omega_limit
  id: variable
  parameters:
    value: '0.035'
  states: {}
- name: gmsk_sps
  id: variable
  parameters:
    value: int(sample_rate/data_rate)
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, sample_rate, cutoff_freq, transition_width)
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '100'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_simple_squelch
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: squelch_threshold
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: gmsk_sps
    sensitivity: (numpy.pi*0.5)/gmsk_sps
  states: {}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '3276800'
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    uri: ip:10.88.110.66
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: unpacked_to_packed
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:55555
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_simple_squelch, '0', freq_xlating_fir_filter_lp, '0']
- [digital_gfsk_demod_0, '0', unpacked_to_packed, '0']
- [freq_xlating_fir_filter_lp, '0', digital_gfsk_demod_0, '0']
- [iio_pluto_source_0, '0', analog_simple_squelch, '0']
- [unpacked_to_packed, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
